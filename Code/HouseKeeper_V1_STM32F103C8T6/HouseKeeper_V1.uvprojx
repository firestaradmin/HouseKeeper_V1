# Keil uVision project HouseKeeper_V1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6_LED灯开关
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Lib\FWLib\inc;.\Lib\CMSIS;.\SYSTEM\delay;.\SYSTEM\TIM;.\SYSTEM\USART;.\HARDWARE\AS608_FP;.\SYSTEM\EXTI;.\HARDWARE\servo;.\USMART;.\HARDWARE\LD3320
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./User/: main.c stm32f10x_it.c sys.c
  group FWLIB
    ./Lib/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ./Lib/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Lib/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group HardWare
    ./HARDWARE/AS608_FP/: as608.c
    ./HARDWARE/servo/: servo.c
  group System
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/TIM/: myTIM.c
    ./SYSTEM/USART/: usart.c
    ./SYSTEM/EXTI/: EXTI.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
